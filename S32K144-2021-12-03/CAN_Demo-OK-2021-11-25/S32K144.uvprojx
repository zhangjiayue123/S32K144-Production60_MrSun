# Keil uVision project S32K144.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144HFxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S32K144 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\platform\devices\S32K144\include;.\VCUAPP;..\VCUS32K144_MDK5;.\driver
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\S32K144_64_flash.sct
  group source
    ./driver/: drvCAN.c drvFLASH.c drvGPIO.c
  group VCUAPP
    ./VCUAPP/: main.c
  group Doc
    ./: readme.txt
software components: CMSIS:CORE 5.0.1, Device:Startup 2.0.0
